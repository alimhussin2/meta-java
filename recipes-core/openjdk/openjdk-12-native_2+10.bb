require openjdk-12-release-${PV}.inc
require openjdk-12-native.inc
