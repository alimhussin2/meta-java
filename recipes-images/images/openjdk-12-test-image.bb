IMAGE_INSTALL_append = " openjdk-12 "

inherit openjdk-test-image
