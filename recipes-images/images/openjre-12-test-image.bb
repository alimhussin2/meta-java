IMAGE_INSTALL_append = " openjre-12 "

inherit openjre-test-image
